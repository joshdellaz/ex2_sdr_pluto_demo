options:
  parameters:
    generate_options: qt_gui
    id: endurosat_e2e
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: baud_bit
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: baud_byte
  id: variable
  parameters:
    value: baud_bit/8
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '437875000'
  states: {}
- name: fsk_dev
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: in_len
  id: variable
  parameters:
    value: '158'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '16'
  states: {}
- name: out_len
  id: variable
  parameters:
    value: '129'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_bit*spsym
  states: {}
- name: samp_rate_frontend
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 2*3.14159265358979323846*(fsk_dev/(baud_bit*spsym))
  states: {}
- name: spsym
  id: variable
  parameters:
    value: '32'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,nfilts,1/float(spsym),0.35,11*spsym*nfilts)
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-50'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_dev)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-35'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '4321'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1234'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: spsym
    sensitivity: sensitivity
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.5'
    max_dev: '0.005'
    osps: '1'
    sps: spsym
    taps: taps
    type: fff
  states: {}
- name: note_0
  id: note
  parameters:
    note: Unpacked
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: GFSK Mod input is packed bytes (eg. 0b01110000)
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: Must have high sample rate for smooth sinusoid
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: UHFDIR cmds
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: CSP Data
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2*baud_bit*spsym
    fc: center_freq
    fftsize: 10*1024
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: spsym*50
    srate: spsym*50
    type: complex
    update_time: '1'
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: baud_bit*spsym*5
    srate: baud_bit*spsym*5
    type: complex
    update_time: '5'
    ylabel: Rx raw
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: baud_bit*spsym*5
    srate: baud_bit*spsym*5
    type: complex
    update_time: '5'
    ylabel: Squelched
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    size: baud_bit*spsym*5
    srate: baud_bit*spsym*5
    type: complex
    update_time: '5'
    ylabel: Rx after filter
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: int(samp_rate_frontend)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate_frontend)
    interp: samp_rate
    type: ccc
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_bit
    iq: 'True'
    samp_rate: spsym*baud_bit
    subaudio: 'False'
  states: {state: disabled}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: int(120)
    sync: '''00100100001001000010010000100100'''
    threshold: '0'
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: center_freq
    gain: tx_gain
    samp_rate: samp_rate_frontend
    type: fc32
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: center_freq
    gain: rx_gain
    samp_rate: samp_rate_frontend
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_socket_pdu_1, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_unpacked_to_packed_xx_0, '0', digital_gfsk_mod_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_binary_slicer_fb_0, '0']
- [rational_resampler_xxx_0, '0', soapy_plutosdr_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [satellites_ax25_deframer_0, out, blocks_socket_pdu_0, pdus]
- [satellites_ax25_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_sync_to_pdu_packed_0_0, out, blocks_socket_pdu_0, pdus]
- [satellites_sync_to_pdu_packed_0_0, out, satellites_hexdump_sink_0, in]
- [soapy_plutosdr_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
